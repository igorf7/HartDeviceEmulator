# Keil uVision project hartDevice.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L051K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hartdevice_debug +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_DEBUG_LEDS DEBUG_VERSION
  c include: ..\CMSIS;..\src\driver;..\src\protocol;..\src\utility;..\src\component;..\src\app\v318hart
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ../src/app/device/: main.c
  group component
    ../src/component/: ledctl.c modem5700.c
  group driver
    ../src/driver/: iwdg.c memory.c ports.c rcc.c spi.c uart.c crc32.c
  group protocol
    ../src/protocol/: hart.c
  group utility
    ../src/utility/: convert.c task.c
  group CMSIS
    ../CMSIS/: stm32l0xx_it.c system_stm32l0xx.c
    ../CMSIS/keil/: startup_stm32l051xx.s
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L051K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: as above
  output: hartDevice_release
  AfterMake: fromelf --bin "./Objects/hartDevice_release.axf" --output "./firmware/hartDevice.bin"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_DEBUG_LEDS
  c include: ..\CMSIS;..\src\utility;..\src\protocol;..\src\driver;..\src\component;..\src\app\v318hart
  memory RVCT4: ROM 0x8003000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x2000
