# Keil uVision project hartLoader.uvprojx, settings and files
target debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L051K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hartLoader_debug
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HART_LOADER DEBUG_VERSION
  c include: ..\src\app\loader;..\src\component;..\src\driver;..\src\protocol;..\CMSIS;..\src\utility
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ../src/app/loader/: main.c
  group component
    ../src/component/: modem5700.c
  group driver
    ../src/driver/: crc32.c lptimer.c memory.c ports.c rcc.c uart.c
  group protocol
    ../src/protocol/: hart_lite.c
  group utility
    ../src/utility/: task.c convert.c
  group CMSIS
    ../CMSIS/: stm32l0xx_it.c system_stm32l0xx.c
    ../CMSIS/keil/: startup_stm32l051xx.s
target release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L051K6Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.3.0
  cpu: as above
  output: hartLoader_release
  AfterMake: fromelf --bin "./Objects/hartLoader_release.axf" --output "./firmware/hartLoader.bin"
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HART_LOADER
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
